# Keil uVision project USB_com_port.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: projecto +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .\STM32_USB-FS-Device_Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c stm32_it.c hw_config.c
  group Header
    ./: stm32_it.h hw_config.h
  group STM32_USB-FS-Device_Lib
    ./STM32_USB-FS-Device_Lib/: hw_config.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_sil.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0
